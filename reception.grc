options:
  parameters:
    generate_options: qt_gui
    id: reception
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '76'
    value: '9'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Tuning
    orient: Qt.Horizontal
    start: 144.0e6
    step: 1.0e3
    stop: 148.0e6
    value: 144.95e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: usrp_rate
    ctrlpanel: 'True'
    fc: '144950000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: usrp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: '200000'
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: Rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: usrp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
