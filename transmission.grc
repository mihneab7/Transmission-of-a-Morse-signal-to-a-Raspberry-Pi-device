options:
  parameters:
    generate_options: qt_gui
    id: transmission
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Tx_gain
  id: variable_qtgui_range
  parameters:
    label: Transmission Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89.8'
    value: '44.9'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency Range
    orient: Qt.Horizontal
    start: 5.6e9
    step: '1'
    stop: 5.72e9
    value: 5.665e9
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(1024*32)
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      guiString = ""

      morseDictionary = {
          "A": "1,0,1,1,1",
          "B": "1,1,1,0,1,0,1,0,1",
          "C": "1,1,1,0,1,0,1,1,1,0,1",
          "D": "1,1,1,0,1,0,1",
          "E": "1",
          "F": "1,0,1,0,1,1,1,0,1",
          "G": "1,1,1,0,1,1,1,0,1",
          "H": "1,0,1,0,1,0,1",
          "I": "1,0,1",
          "J": "1,0,1,1,1,0,1,1,1,0,1,1,1",
          "K": "1,1,1,0,1,0,1,1,1",
          "L": "1,0,1,1,1,0,1,0,1",
          "M": "1,1,1,0,1,1,1",
          "N": "1,1,1,0,1",
          "O": "1,1,1,0,1,1,1,0,1,1,1",
          "P": "1,0,1,1,1,0,1,1,1,0,1",
          "Q": "1,1,1,0,1,1,1,0,1,0,1,1,1",
          "R": "1,0,1,1,1,0,1",
          "S": "1,0,1,0,1",
          "T": "1,1,1",
          "U": "1,0,1,0,1,1,1",
          "V": "1,0,1,0,1,0,1,1,1",
          "W": "1,0,1,1,1,0,1,1,1",
          "X": "1,1,1,0,1,0,1,0,1,1,1",
          "Y": "1,1,1,0,1,0,1,1,1,0,1,1,1",
          "Z": "1,1,1,0,1,1,1,0,1,0,1",
          " ": "0",            
          "1": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "2": "1,0,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "3": "1,0,1,0,1,0,1,1,1,0,1,1,1",
          "4": "1,0,1,0,1,0,1,0,1,1,1",
          "5": "1,0,1,0,1,0,1,0,1",
          "6": "1,1,1,0,1,0,1,0,1,0,1",
          "7": "1,1,1,0,1,1,1,0,1,0,1,0,1",
          "8": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1",
          "9": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",
          "0": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          ".": "1,0,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1",          
          ",": "1,1,1,0,1,1,1,0,1,0,1,0,1,1,1,0,1,1,1",      
          ":": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1",          
          "?": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1",              
          "'": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",      
          "-": "1,1,1,0,1,0,1,0,1,0,1,0,1,1,1",              
          "/": "1,1,1,0,1,0,1,0,1,1,1,0,1",                  
          "(": "1,1,1,0,1,0,1,1,1,0,1,1,1,0,1",              
          ")": "1,1,1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1",      
          "\"": "1,0,1,1,1,0,1,0,1,0,1,1,1,0,1",             
          "=": "1,1,1,0,1,0,1,0,1,0,1,1,1",                  
          "+": "1,0,1,1,1,0,1,0,1,1,1,0,1",                  
          "@": "1,0,1,1,1,0,1,1,1,0,1,0,1,1,1,0,1",           
          "!": "1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1,1,1",      
          "&": "1,0,1,1,1,0,1,0,1,0,1",                      
          ";": "1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1",          
          "_": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1",          
          "$": "1,0,1,0,1,0,1,1,1,0,1,0,1,0,1,1,1"           
          }

      class blk(gr.sync_block):  
          """Binary Morse Encoder"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name = 'Binary Morse Encoder',   # will show up in GRC
                  in_sig = None,
                  out_sig = [np.byte]
              )

              self.message_port_register_out(pmt.intern("Clear"))
              self.message_port_register_in(pmt.intern("inputMessage"))
              self.set_msg_handler(pmt.intern("inputMessage"), self.guiMessage)
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def guiMessage(self, message):

              global guiString

              coordinateFile = open("/home/mihneab/PycharmProjects/Licenta/coordinates.txt", "r")
              fileRead = coordinateFile.read() 
            
              guiString += fileRead
              guiString += " "        
              guiString += pmt.symbol_to_string(message)
              guiString = guiString.replace("\n", "")

              print(guiString)

          def work(self, input_items, output_items):
              """Turn GPS coordinates and the input message in binary"""
              global morseDictionary
              global guiString

              bits = ""

              if (len (guiString) > 0):
                  for element in guiString:
                      # convert to string in case there are just numbers
                      stringElement = str(element)
                      # convert to upper case
                      character = stringElement.upper()
                      # check if the character is in the dictionary
                      if (not(character in morseDictionary)):
                          # unknown characters are replaced with ?                        
                          character = "?" 
                      # save the morse character in a variable       
                      morseCh = str(morseDictionary.get(character))
                      # concatenate it to the bit string, 0,0,0 is the space between characters
                      bits += (morseCh + ",0,0,0,")
                  
                  # concatenate 0,0,0,0 to mark the word's end
                  bits += "0,0,0,0"

                  # get the length of the string, commas included
                  length = len(bits)
                  # obtain number of commas
                  commaNumber = bits.count(",")
                  # obtain the number of elements, no commas included
                  elementNumber = length - commaNumber
                  # split by comma
                  bitsSplit = bits.split(",")
                  length = len(bitsSplit)

                  # write the values in the output
                  for i in range(length):
                      output_items[0][i] = bitsSplit[i]
                  
                  # update the message edit box
                  guiString = ""
                  self.message_port_pub(pmt.intern('Clear'), pmt.intern(""))
              # in case there is no input        
              else:
                  elementNumber = 0
              # not relevant
              return(elementNumber)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, path='/home/mihneab/PycharmProjects/Licenta/coordinates.txt'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name = 'GPS Source',   # will show up in GRC
                  in_sig = None,
                  out_sig = [np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).m
              self.path = path

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # read the acquired coordinates and process them        
              file = open(self.path, "r")
              interm = file.read()
              listInterm = interm.split()
              length = len(listInterm)
              
              # since 2 float/double values are expected, they can be written directly to the output
              output_items[0][0] = listInterm[0]
              output_items[0][1] = listInterm[1]
              
              # write the output in a file for viewing
              file = open("/home/mihneab/PycharmProjects/Licenta/testGPS.txt", "w")
              file.write(str(output_items[0][0]))
              file.write(" ")
              file.write(str(output_items[0][1]))
              file.close()
              return len(output_items[0][:length])
    path: '''/home/mihneab/PycharmProjects/Licenta/coordinates.txt'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      # shorter dictionary since only digits, periods and spaces are expected
      shortMorseDictionary = {
          " ": "0",            
          "1": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "2": "1,0,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "3": "1,0,1,0,1,0,1,1,1,0,1,1,1",
          "4": "1,0,1,0,1,0,1,0,1,1,1",
          "5": "1,0,1,0,1,0,1,0,1",
          "6": "1,1,1,0,1,0,1,0,1,0,1",
          "7": "1,1,1,0,1,1,1,0,1,0,1,0,1",
          "8": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1",
          "9": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",
          "0": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          ".": "1,0,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1",         
          "?": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1"    
          }


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Binary Morse Encoder (GPS)',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              global shortMorseDictionary

              bits = ""
              # read the GPS coordinates
              file = open("/home/mihneab/PycharmProjects/Licenta/testGPS.txt", "r")
              intermediary = file.read()
              file.close()
              # similar check with the main encoder
              for character in intermediary:
                  if (not(character in shortMorseDictionary)):
                      character = "?"
                  dots = str(shortMorseDictionary.get(character))
                  bits = bits + dots
                  bits = bits + ",0,0,0,"
              # write the result in a file
              file2 = open("/home/mihneab/PycharmProjects/Licenta/testGPS2.txt", "w")
              file2.write(bits)
              file2.close()

              return len(bits)
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name = 'Combine the message with GPS coordinates',   # will show up in GRC
                  in_sig = [np.byte],
                  out_sig = [np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """This should combine GPS coordinates and the input message seamlessly"""
              # read the encoded GPS coordinates
              file = open("/home/mihneab/PycharmProjects/Licenta/testGPS2.txt", "r")
              lines = file.read()
              file.close()

              goodString = ""
             
              # remove whitespace from the end, split by comma
              lines = lines[:-1]            
              lines = lines.strip()
              intermediary = lines.split(",")
              
              # add the bits in a string
              for bit in intermediary:
                  goodString += str(bit)

              # read the input from the binary morse encoder block and process it
              inputMessage = str(input_items[0])
              inputMessage = inputMessage.replace("[", "")
              inputMessage = inputMessage.replace("]", "")
              inputMessage = inputMessage.replace(" ", "")
              # combine the GPS coordinates and the input message
              finalMessage = goodString + inputMessage

              # write them to the output
              for i in range(len(finalMessage)):
                  output_items[0][:] = finalMessage[i]
              
              # write them in a file in order to be checked
              file = open("/home/mihneab/PycharmProjects/Licenta/testGPS3.txt", "w")
              file.write(str(output_items[0][:]))
              file.close()        

              return len(output_items[0])
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    type: string
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1e3
    ctrlpanel: 'True'
    fc: 5.665e9
    fftsize: '1024'
    name: Morse signal spectrum before transmission
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Morse signal in time before transmission
    size: '1024'
    srate: 256*256
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 200e3
    center_freq0: frequency
    clock_rate: '32000000'
    dev_args: '""'
    gain0: Tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: '128000'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_0, '0', uhd_usrp_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, '0', blocks_uchar_to_float_0, '0']
- [epy_block_0, '0', epy_block_3, '0']
- [epy_block_0, Clear, qtgui_edit_box_msg_0, val]
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_3, '0', blocks_repeat_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0, inputMessage]

metadata:
  file_format: 1
